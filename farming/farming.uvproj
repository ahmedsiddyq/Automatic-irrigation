# Keil uVision project farming.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F303 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: farming +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: farming.c stdutils.h i2c.h i2c.c eeprom.c delay.h delay.c
    ../sidyq headers/: eeprom.h lcd.h
